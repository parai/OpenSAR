<?xml version='1.0' encoding='utf-8'?>
<AUTOSAR><OS><General ErrorHook="ErrorHook" PostTaskHook="PostTaskHook" PreTaskHook="PreTaskHook" ProtectionHook="NULL" ShutdownHook="ShutdownHook" StartupHook="StartupHook" /><TaskList Max="TBD"><Task Activation="1" Autostart="True" Name="Task100ms" Priority="5" Schedule="FULL" StackSize="512" /><Task Activation="1" Autostart="True" Name="Task1000ms" Priority="10" Schedule="FULL" StackSize="512"><EventList Max="TBD"><Event Mask="0x01" Name="Event1" /><Event Mask="0x02" Name="Event2" /><Event Mask="0x04" Name="Event3" /><Event Mask="0x08" Name="Event4" /><Event Mask="0x10" Name="Event5" /><Event Mask="0x20" Name="Event1000ms" /></EventList></Task><Task Activation="1" Autostart="True" Name="SchM_Startup" Priority="16" Schedule="NON" StackSize="512" /><Task Activation="1" Autostart="True" Name="SchM_BswService" Priority="5" Schedule="FULL" StackSize="512" /><Task Activation="1" Autostart="True" Name="Task10ms" Priority="10" Schedule="FULL" StackSize="512" /><Task Activation="1" Autostart="True" Name="Task20ms" Priority="10" Schedule="FULL" StackSize="512" /></TaskList><AlarmList Max="TBD"><Alarm Action="ActivateTask" Autostart="Relative" Callback="TBD" Counter="SystemCounter" Event="TBD" Name="Alarm10ms" Period="10" StartTime="10" Task="Task10ms" /><Alarm Action="ActivateTask" Autostart="Relative" Callback="TBD" Counter="SystemCounter" Event="TBD" Name="Alarm20ms" Period="20" StartTime="10" Task="Task20ms" /><Alarm Action="ActivateTask" Autostart="Relative" Callback="TBD" Counter="SystemCounter" Event="TBD" Name="Alarm100ms" Period="100" StartTime="10" Task="Task100ms" /><Alarm Action="ActivateTask" Autostart="False" Callback="TBD" Counter="SystemCounter" Event="TBD" Name="Alarm_BswService" Period="5" StartTime="0" Task="SchM_BswService" /><Alarm Action="ActivateTask" Autostart="Relative" Callback="TBD" Counter="SystemCounter" Event="TBD" Name="Alarm1000ms" Period="1000" StartTime="10" Task="Task1000ms" /></AlarmList><CounterList Max="TBD"><Counter MaxAllowed="0xFFFF" MinCycle="1" Name="SystemCounter" TicksPerBase="1" /></CounterList><ResourceList Max="TBD" /></OS><EucC><PduList Max="TBD"><Pdu Name="Pdu1" Size="64" /><Pdu Name="Pdu2" Size="64" /><Pdu Name="Pdu3" Size="64" /><Pdu Name="Pdu4" Size="64" /></PduList></EucC><Can><General DevelopmentErrorDetection="OFF" VersionInfoApi="OFF" /><ControllerList Max="TBD"><Controller Baudrate="500" Name="CAN_CTRL_0" Seg1="13" Seg2="2"><HohList Max="TBD"><Hoh HohType="BASIC" IdentifierType="STANDARD" Name="Can0Hrh" ObjectType="RECEIVE" /><Hoh HohType="BASIC" IdentifierType="STANDARD" Name="Can0Hth" ObjectType="TRANSMIT" /></HohList></Controller><Controller Baudrate="500" Name="CAN_CTRL_2" Seg1="13" Seg2="2"><HohList Max="TBD"><Hoh HohType="BASIC" IdentifierType="STANDARD" Name="Can2Hrh" ObjectType="RECEIVE" /><Hoh HohType="BASIC" IdentifierType="STANDARD" Name="Can2Hth" ObjectType="TRANSMIT" /></HohList></Controller></ControllerList></Can><CanIf><General BusOffNotification="CanIf_User_BusoffNotification" DataLengthCodeCheck="ON" DevelopmentErrorDetection="OFF" ErrorNotification="CanIf_User_ErrorNotification" VersionInfoApi="OFF" /><ChannelList Max="TBD"><Channel ControllerRef="CAN_CTRL_0" Name="LS_BUS"><HthList Max="TBD"><Hth HthRef="Can0Hth" Name="LS_Hth" /></HthList><HrhList Max="TBD"><Hrh HrhRef="Can0Hrh" Name="LS_Hrh" SoftwareFilterUsed="True" /></HrhList></Channel><Channel ControllerRef="CAN_CTRL_2" Name="HS_BUS"><HthList Max="TBD"><Hth HthRef="Can2Hth" Name="HS_Hth" /></HthList><HrhList Max="TBD"><Hrh HrhRef="Can2Hrh" Name="HS_Hrh" SoftwareFilterUsed="True" /></HrhList></Channel></ChannelList></CanIf><COM><BusList Max="TBD"><Bus Baudrate="TBD" Name="Bus1" Seg1="TBD" Seg2="TBD" SyncSeg="TBD" /><Bus Baudrate="TBD" Name="Bus2" Seg1="TBD" Seg2="TBD" SyncSeg="TBD" /></BusList><TxPduList Max="TBD"><Pdu Bus="TBD" Format="Motorola" Identifier="TBD" Name="Pdu1" Period="100" TxMode="PERIODIC"><SignalList Max="TBD"><Signal InitialValue="0" Name="Signal1" Size="8" StartBit="TBD" TransferProperty="PENDING" Type="uint8" UpdateBitPosition="TBD" UpdateBitUsed="False" /></SignalList></Pdu></TxPduList><RxPduList Max="TBD"><Pdu Bus="Bus1" Format="Motorola" Identifier="TBD" Name="Pdu1" RxMode="PERIODIC" Timeout="2000" TimeoutNotification="TBD"><SignalList Max="TBD"><Signal InitialValue="0" Name="Signal1" Size="8" StartBit="TBD" TransferProperty="PENDING" Type="uint8" UpdateBitPosition="TBD" UpdateBitUsed="False" /></SignalList></Pdu></RxPduList></COM></AUTOSAR>