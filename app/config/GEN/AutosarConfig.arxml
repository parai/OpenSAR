<?xml version='1.0' encoding='utf-8'?>
<AUTOSAR><OS><General Comment="*" ErrorHook="ErrorHook" PostTaskHook="PostTaskHook" PreTaskHook="PreTaskHook" ProtectionHook="NULL" ShutdownHook="ShutdownHook" StartupHook="StartupHook" /><TaskList Max="TBD"><Task Activation="1" Autostart="True" Comment="*" Name="Task100ms" Priority="5" Schedule="FULL" StackSize="512" /><Task Activation="1" Autostart="True" Comment="*" Name="Task1000ms" Priority="10" Schedule="FULL" StackSize="512"><EventList Max="TBD"><Event Comment="*" Mask="0x01" Name="Event1" /><Event Comment="*" Mask="0x02" Name="Event2" /><Event Comment="*" Mask="0x04" Name="Event3" /><Event Comment="*" Mask="0x08" Name="Event4" /><Event Comment="*" Mask="0x10" Name="Event5" /><Event Comment="*" Mask="0x20" Name="Event1000ms" /></EventList></Task><Task Activation="1" Autostart="True" Comment="*" Name="SchM_Startup" Priority="16" Schedule="NON" StackSize="512" /><Task Activation="1" Autostart="True" Comment="*" Name="SchM_BswService" Priority="5" Schedule="FULL" StackSize="512" /><Task Activation="1" Autostart="True" Comment="*" Name="Task10ms" Priority="10" Schedule="FULL" StackSize="512" /><Task Activation="1" Autostart="True" Comment="*" Name="Task20ms" Priority="10" Schedule="FULL" StackSize="512" /></TaskList><AlarmList Max="TBD"><Alarm Action="ActivateTask" Autostart="Relative" Callback="TBD" Comment="*" Counter="SystemCounter" Event="TBD" Name="Alarm10ms" Period="10" StartTime="10" Task="Task10ms" /><Alarm Action="ActivateTask" Autostart="Relative" Callback="TBD" Comment="*" Counter="SystemCounter" Event="TBD" Name="Alarm20ms" Period="20" StartTime="10" Task="Task20ms" /><Alarm Action="ActivateTask" Autostart="Relative" Callback="TBD" Comment="*" Counter="SystemCounter" Event="TBD" Name="Alarm100ms" Period="100" StartTime="10" Task="Task100ms" /><Alarm Action="ActivateTask" Autostart="False" Callback="TBD" Comment="*" Counter="SystemCounter" Event="TBD" Name="Alarm_BswService" Period="5" StartTime="0" Task="SchM_BswService" /><Alarm Action="ActivateTask" Autostart="Relative" Callback="TBD" Comment="*" Counter="SystemCounter" Event="TBD" Name="Alarm1000ms" Period="1000" StartTime="10" Task="Task1000ms" /></AlarmList><CounterList Max="TBD"><Counter Comment="*" MaxAllowed="0xFFFF" MinCycle="1" Name="SystemCounter" TicksPerBase="1" /></CounterList><ResourceList Max="TBD" /></OS><EcuC><PduList Max="TBD"><Pdu Comment="*" Name="TxDiagP2P" Size="64" /><Pdu Comment="*" Name="RxDiagP2P" Size="64" /><Pdu Comment="*" Name="TxDiagP2A" Size="64" /><Pdu Comment="*" Name="RxDiagP2A" Size="64" /><Pdu Comment="*" Name="TxMsgTime" Size="64" /><Pdu Comment="*" Name="RxMsgAbsInfo" Size="64" /></PduList></EcuC><Can><General Comment="*" DevelopmentErrorDetection="OFF" VersionInfoApi="OFF" /><ControllerList Max="TBD"><Controller Baudrate="500" Comment="*" Name="CAN_CTRL_0" Seg1="13" Seg2="2"><HohList Max="TBD"><Hoh Comment="*" HohType="BASIC" IdentifierType="STANDARD" Name="Can0Hrh" ObjectType="RECEIVE" /><Hoh Comment="*" HohType="BASIC" IdentifierType="STANDARD" Name="Can0Hth" ObjectType="TRANSMIT" /></HohList></Controller><Controller Baudrate="500" Comment="*" Name="CAN_CTRL_2" Seg1="13" Seg2="2"><HohList Max="TBD"><Hoh Comment="*" HohType="BASIC" IdentifierType="STANDARD" Name="Can2Hrh" ObjectType="RECEIVE" /><Hoh Comment="*" HohType="BASIC" IdentifierType="STANDARD" Name="Can2Hth" ObjectType="TRANSMIT" /></HohList></Controller></ControllerList></Can><CanIf><General BusOffNotification="CanIf_User_BusoffNotification" Comment="*" DataLengthCodeCheck="ON" DevelopmentErrorDetection="OFF" ErrorNotification="CanIf_User_ErrorNotification" VersionInfoApi="OFF" /><ChannelList Max="TBD"><Channel Comment="*" ControllerRef="CAN_CTRL_0" Name="LS_BUS"><HthList Max="TBD"><Hth Comment="*" HthRef="Can0Hth" Name="LS_Hth"><PduList Max="TBD"><Pdu Comment="*" DataLengthCode="8" EcuCPduRef="TxDiagP2P" Identifier="0x732" Name="P2P" TransmitNotifier="PduR" UserNotification="CanIf_UserTxConfirmation" /><Pdu Comment="*" DataLengthCode="8" EcuCPduRef="TxDiagP2A" Identifier="0x742" Name="P2A" TransmitNotifier="PduR" UserNotification="CanIf_UserTxConfirmation" /></PduList></Hth></HthList><HrhList Max="TBD"><Hrh Comment="*" HrhRef="Can0Hrh" Name="LS_Hrh" SoftwareFilterUsed="True"><PduList Max="TBD"><Pdu Comment="*" DataLengthCode="8" EcuCPduRef="RxDiagP2P" FilterMask="0xFFF" Identifier="0x731" Name="P2P" ReceivedNotifier="PduR" UserNotification="CanIf_UserRxIndication" /><Pdu Comment="*" DataLengthCode="8" EcuCPduRef="RxDiagP2A" FilterMask="0xFFF" Identifier="0x741" Name="P2A" ReceivedNotifier="PduR" UserNotification="CanIf_UserRxIndication" /></PduList></Hrh></HrhList></Channel><Channel Comment="*" ControllerRef="CAN_CTRL_2" Name="HS_BUS"><HthList Max="TBD"><Hth Comment="*" HthRef="Can2Hth" Name="HS_Hth" /></HthList><HrhList Max="TBD"><Hrh Comment="*" HrhRef="Can2Hrh" Name="HS_Hrh" SoftwareFilterUsed="True" /></HrhList></Channel></ChannelList></CanIf><CanTp><General Comment="*" DevelopmentErrorDetection="OFF" VersionInfoApi="OFF" /><RxSduList Max="TBD"><Sdu BS="8" Comment="*" CommunicationType="PHYSICAL" MaxBusyTransmission="TBD" Name="SduP2P" Nar="1" Nbr="100" Ncr="1" Padding="ON" RxPduRef="RxDiagP2P" STmin="1" TxFcPduRef="TxDiagP2P" /><Sdu BS="8" Comment="*" CommunicationType="PHYSICAL" MaxBusyTransmission="TBD" Name="SduP2A" Nar="1" Nbr="100" Ncr="1" Padding="ON" RxPduRef="RxDiagP2A" STmin="1" TxFcPduRef="TxDiagP2A" /></RxSduList><TxSduList Max="TBD"><Sdu Comment="*" CommunicationType="PHYSICAL" Name="SduP2P" Nas="1" Nbs="100" Ncs="1" Padding="ON" RxFcPduRef="RxDiagP2P" TxPduRef="TxDiagP2P" /><Sdu Comment="*" CommunicationType="PHYSICAL" Name="SduP2A" Nas="1" Nbs="100" Ncs="1" Padding="ON" RxFcPduRef="RxDiagP2A" TxPduRef="TxDiagP2A" /></TxSduList></CanTp><PduR><General CanIfUsed="True" CanTpUsed="True" ComUsed="True" Comment="*" DcmUsed="True" DevelopmentErrorDetection="OFF" J1939TpUsed="False" LinIfUsed="False" LinTpUsed="False" VersionInfoApi="OFF" ZeroCostIf="CanIf" ZeroCostOperationMode="OFF" ZeroCostTp="CanTp" /><RoutineList Max="TBD"><Source Comment="*" Module="Dcm" Name="DcmP2P" PudRef="TxDiagP2P"><DestinationList Max="TBD"><Destination Comment="*" Module="CanTp" Name="CanTpP2P" PudRef="TxDiagP2P" /></DestinationList></Source><Source Comment="*" Module="CanTp" Name="CanTpP2P" PudRef="RxDiagP2P"><DestinationList Max="TBD"><Destination Comment="*" Module="Dcm" Name="DcmP2P" PudRef="RxDiagP2P" /></DestinationList></Source><Source Comment="*" Module="Dcm" Name="DcmP2A" PudRef="TxDiagP2A"><DestinationList Max="TBD"><Destination Comment="*" Module="CanTp" Name="CanTpP2A" PudRef="TxDiagP2A" /></DestinationList></Source><Source Comment="*" Module="CanTp" Name="CanTpP2A" PudRef="RxDiagP2A"><DestinationList Max="TBD"><Destination Comment="*" Module="Dcm" Name="DcmP2A" PudRef="RxDiagP2A" /></DestinationList></Source></RoutineList></PduR><Com><General Comment="*" DevelopmentErrorDetection="OFF" VersionInfoApi="OFF" /><PduGroupList Max="TBD"><PduGroup Comment="*" Name="PduGroup1" /></PduGroupList><IPduList Max="TBD"><IPdu Callout="NULL" Comment="*" DefaultValueForUnusedArea="0x5A" Direction="SEND" Name="MsgTime" NumberOfRepetions="0" PduGroupRef="PduGroup1" PudRef="TxMsgTime" RepetionsPeriodFactor="10" RxSignalProcessing="DEFERRED" TimeOffsetFactor="0" TimePeriodFactor="100" TxMinimumDelayFactor="1" TxMode="PERIODIC"><GroupSignalList Max="TBD"><GroupSignal Comment="*" Endianess="BIG_ENDIAN" FirstTimeoutFactor="TBD" Name="SystemTime" ReceivedNotification="NULL" Size="64" StartBit="0" TimeoutAction="NONE" TimeoutFactor="TBD" TimeoutNotification="NULL" TransferProperty="PENDING" UpdateBitPosition="TBD" UpdateBitUsed="False"><SignalList Max="TBD"><Signal Comment="*" Endianess="BIG_ENDIAN" InitialValue="2013" Name="year" Size="16" StartBit="0" Type="uint16" UpdateBitPosition="TBD" UpdateBitUsed="False" /><Signal Comment="*" Endianess="BIG_ENDIAN" InitialValue="12" Name="month" Size="8" StartBit="16" Type="uint8" UpdateBitPosition="TBD" UpdateBitUsed="False" /><Signal Comment="*" Endianess="BIG_ENDIAN" InitialValue="15" Name="day" Size="8" StartBit="24" Type="uint8" UpdateBitPosition="TBD" UpdateBitUsed="False" /><Signal Comment="*" Endianess="BIG_ENDIAN" InitialValue="19" Name="hour" Size="8" StartBit="32" Type="uint8" UpdateBitPosition="TBD" UpdateBitUsed="False" /><Signal Comment="*" Endianess="BIG_ENDIAN" InitialValue="49" Name="minute" Size="8" StartBit="40" Type="uint8" UpdateBitPosition="TBD" UpdateBitUsed="False" /><Signal Comment="*" Endianess="BIG_ENDIAN" InitialValue="0" Name="second" Size="8" StartBit="48" Type="uint8" UpdateBitPosition="TBD" UpdateBitUsed="False" /></SignalList></GroupSignal></GroupSignalList></IPdu><IPdu Callout="NULL" Comment="*" DefaultValueForUnusedArea="0x5A" Direction="RECEIVE" Name="AbsInfo" NumberOfRepetions="0" PduGroupRef="PduGroup1" PudRef="RxMsgAbsInfo" RepetionsPeriodFactor="10" RxSignalProcessing="DEFERRED" TimeOffsetFactor="0" TimePeriodFactor="10" TxMinimumDelayFactor="1" TxMode="PERIODIC"><SignalList Max="TBD"><Signal Comment="*" Endianess="BIG_ENDIAN" FirstTimeoutFactor="100" InitialValue="0" Name="VehicleSpeed" ReceivedNotification="NULL" Size="16" StartBit="0" TimeoutAction="NONE" TimeoutFactor="100" TimeoutNotification="NULL" TransferProperty="PENDING" Type="uint16" UpdateBitPosition="TBD" UpdateBitUsed="False" /><Signal Comment="*" Endianess="BIG_ENDIAN" FirstTimeoutFactor="100" InitialValue="0" Name="TachoSpeed" ReceivedNotification="NULL" Size="16" StartBit="16" TimeoutAction="NONE" TimeoutFactor="100" TimeoutNotification="NULL" TransferProperty="PENDING" Type="uint16" UpdateBitPosition="TBD" UpdateBitUsed="False" /><Signal Comment="*" Endianess="BIG_ENDIAN" FirstTimeoutFactor="500" InitialValue="0" Name="Led1Sts" ReceivedNotification="NULL" Size="2" StartBit="32" TimeoutAction="NONE" TimeoutFactor="500" TimeoutNotification="NULL" TransferProperty="PENDING" Type="uint8" UpdateBitPosition="TBD" UpdateBitUsed="False" /><Signal Comment="*" Endianess="BIG_ENDIAN" FirstTimeoutFactor="500" InitialValue="0" Name="Led2Sts" ReceivedNotification="NULL" Size="2" StartBit="34" TimeoutAction="NONE" TimeoutFactor="500" TimeoutNotification="NULL" TransferProperty="PENDING" Type="uint8" UpdateBitPosition="TBD" UpdateBitUsed="False" /><Signal Comment="*" Endianess="BIG_ENDIAN" FirstTimeoutFactor="500" InitialValue="0" Name="Led3Sts" ReceivedNotification="NULL" Size="2" StartBit="36" TimeoutAction="NONE" TimeoutFactor="500" TimeoutNotification="NULL" TransferProperty="PENDING" Type="uint8" UpdateBitPosition="TBD" UpdateBitUsed="False" /></SignalList></IPdu></IPduList></Com><Dcm><General Comment="*" DevelopmentErrorDetection="OFF" MaxPeriodDIDNumber="8" PeriodicDIDFastModeTime="50" PeriodicDIDMediumModeTime="100" PeriodicDIDSlowModeTime="200" VersionInfoApi="OFF" /><BufferList Max="TBD"><Buffer Comment="*" Name="Buffer1" Size="512" /><Buffer Comment="*" Name="Buffer2" Size="512" /></BufferList><SessionList Max="TBD"><Session Comment="*" Identifier="1" Name="DS" P2ServerMaxTimeMs="5000" P2StartServerMaxTimeMs="500" /><Session Comment="*" Identifier="2" Name="PRGS" P2ServerMaxTimeMs="5000" P2StartServerMaxTimeMs="500" /><Session Comment="*" Identifier="3" Name="EXTDS" P2ServerMaxTimeMs="5000" P2StartServerMaxTimeMs="500" /></SessionList><SecurityList Max="TBD"><Security Comment="*" CompareKeyCallback="Diag_CompareSeed" GetSeedCallback="Diag_GetSeed" Identifier="5" KeySize="4" Name="DS" SeedSize="4" /><Security Comment="*" CompareKeyCallback="Diag_CompareSeed" GetSeedCallback="Diag_GetSeed" Identifier="6" KeySize="4" Name="PRGS" SeedSize="4" /><Security Comment="*" CompareKeyCallback="Diag_CompareSeed" GetSeedCallback="Diag_GetSeed" Identifier="7" KeySize="4" Name="EXTDS" SeedSize="4" /></SecurityList><DIDControlRecordList Max="TBD"><DIDControlRecord Comment="*" EnableMaskSize="0" Name="DIDControlRecord1" OptionSize="0" StatusSize="0" /><DIDControlRecord Comment="*" EnableMaskSize="0" Name="DIDControlRecord2" OptionSize="0" StatusSize="0" /></DIDControlRecordList><DIDInfoList Max="TBD"><DIDInfo Comment="*" DynamicDefined="True" FixedLength="False" Name="DIDInfo1" ScalingInfoSize="0"><ControlAccess Comment="*" EnableFreezeCurrentState="False" EnableResetToDefault="False" EnableReturnControlToEcu="False" EnableShortTermAdjustment="False" FreezeCurrentStateControlRef="TBD" Name="ControlAccess1" ResetToDefaultRef="=True)" ReturnControlToEcuRef="TBD" ShortTermAdjustmentRef="TBD"><SessionList Max="TBD"><Session Comment="*" Name="DS" /><Session Comment="*" Name="PRGS" /><Session Comment="*" Name="EXTDS" /></SessionList><SecurityList Max="TBD"><Security Comment="*" Name="DS" /><Security Comment="*" Name="PRGS" /><Security Comment="*" Name="EXTDS" /></SecurityList></ControlAccess></DIDInfo></DIDInfoList></Dcm></AUTOSAR>