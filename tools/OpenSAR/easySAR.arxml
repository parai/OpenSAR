<?xml version='1.0' encoding='utf-8'?>
<AUTOSAR>
<OS>
<TaskList Max="255">
	<Task  Name="Text" Priority="Integer" Schedule="Enum FULL NON MIXED" StackSize="Integer" Activation="Integer" Autostart="Boolean">
	<EventList Max="32">
	<Event Name="Text" Mask="Text"/>
	</EventList>
	</Task>
</TaskList>
<AlarmList Max="255">
	<Alarm Name="Text" >
	</Alarm>
</AlarmList>
<CounterList Max="255">
	<Counter Name="Text" >
	</Counter>
</CounterList>
</OS>
</AUTOSAR>
