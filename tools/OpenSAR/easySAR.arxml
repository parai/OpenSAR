<?xml version='1.0' encoding='utf-8'?>
<AUTOSAR>
<OS>
	<General
		StartupHook="Text Default=StartupHook Comment=(if NULL,no StartupHook) PosGUI=0"
		ProtectionHook="Text Default=ProtectionHook Comment=(if NULL,no ProtectionHook) PosGUI=1"
		ShutdownHook="Text Default=ShutdownHook Comment=(if NULL,no ShutdownHook) PosGUI=2"
		ErrorHook="Text Default=ErrorHook Comment=(if NULL,no ErrorHook) PosGUI=3"
		PreTaskHook="Text Default=PreTaskHook Comment=(if NULL,no PreTaskHook) PosGUI=4"
		PostTaskHook="Text Default=PostTaskHook Comment=(if NULL,no PostTaskHook) PosGUI=5"
	/>
	<TaskList Max="255">
		<Task  
			Name="Text Comment=(Task Name) PosGUI=0" 
			Priority="Integer Default=32 Range=0~255 PosGUI=1" 
			Schedule="Enum=(FULL,NON,MIXED) Default=FULL PosGUI=2" 
			StackSize="Integer Range=0~65535 Default=512 PosGUI=3" 
			Activation="Integer Range=1~255 Default=1 PosGUI=4" 
			Autostart="Boolean Default=True PosGUI=5" >
		<EventList Max="32">
		<Event 
			Name="Text PosGUI=0" 
			Mask="Text Comment=(if TBD, then a unique mask will be calculated out when generate OS) PosGUI=1">
		</Event>
		</EventList>
		</Task>
	</TaskList>
	<AlarmList Max="255">
		<Alarm 
			Name="Text PosGUI=0" 
			Counter="EnumRef=OS.CounterList PosGUI=1"
			Action="Enum=(ActivateTask,SetEvent,Callback) Default=ActivateTask PosGUI=2"
			Task="EnumRef=OS.TaskList Enabled=(Self.Action==ActivateTask || Self.Action==SetEvent) PosGUI=3"
			Event="EnumRef=OS.TaskList.(Self.Task).EventList Enabled=(Self.Action==SetEvent) PosGUI=4"
			Callback="Text Enabled=(Self.Action==Callback) PosGUI=5"
			Autostart="Enum=(False,Absolute,Relative) Default=False PosGUI=6"
			StartTime="Integer Range=0~65525 Enabled=(Self.Autostart!=False) Default=0 PosGUI=7"
			Period="Integer Range=0~65535 Enabled=(Self.Autostart!=False) Default=100 PosGUI=8">
		</Alarm>
	</AlarmList>
	<CounterList Max="255">
		<Counter 
			Name="Text Comment=(The first counter is treated as system tick counter) PosGUI=0" 
			MaxAllowed="Integer Range=0~0xFFFFFFFF Default=0xFFFF PosGUI=1"
			TicksPerBase="Integer Range=0~0xFFFF Default=1 Enabled=(False) PosGUI=2"
			MinCycle="Integer Range=0~0xFFFF Default=1 PosGUI=3">
		</Counter>
	</CounterList>
	<ResourceList Max="255">
		<Resource 
			Name="Text PosGUI=0">
		</Resource>
	</ResourceList>
</OS>
<EcuC>
	<PduList Max="65535">
		<Pdu
			Name="Text PosGUI=0"
			Size="Integer Default=64 Range=1~64 PosGUI=1 Unit=Bit"
		/>
	</PduList>
</EcuC>
<Can>
	<General
		DevelopmentErrorDetection="Enum=(ON,OFF) Default=OFF PosGUI=0"
		VersionInfoApi="Enum=(ON,OFF) Default=OFF PosGUI=1"
		>
	</General>
	<ControllerList Max="5">
		<Controller
			Name="Enum=(CAN_CTRL_0,CAN_CTRL_1,CAN_CTRL_2,CAN_CTRL_3,CAN_CTRL_4) PosGUI=0"
			Baudrate="Integer Range=1~12000000 Default=500 Unit=kbps PosGUI=1"
			Seg1="Integer Range=1~16 Default=13 PosGUI=2"
			Seg2="Integer Range=1~8 Default=2 PosGUI=3"
			>
			<HohList Max="65535">
				<Hoh
					Name="Text Comment=(Name must be unique) PosGUI=0"
					HohType="Enum=(BASIC,FULL) Default=BASIC PosGUI=1"
					IdentifierType="Enum=(STANDARD,EXTENDED) Default=STANDARD PosGUI=2"
					ObjectType="Enum=(TRANSMIT,RECEIVE) PosGUI=3"
					/>
			</HohList>
		</Controller>
	</ControllerList>
</Can>
<CanIf>
	<General
		DevelopmentErrorDetection="Enum=(ON,OFF) Default=OFF PosGUI=0"
		VersionInfoApi="Enum=(ON,OFF) Default=OFF PosGUI=1"
		BusOffNotification="Text Default=CanIf_User_BusoffNotification PosGUI=2"
		ErrorNotification="Text Default=CanIf_User_ErrorNotification PosGUI=3"
		DataLengthCodeCheck="Enum=(ON,OFF) Default=ON PosGUI=4"
		>
	</General>	
	<ChannelList Max="65535">
		<Channel
			Name="Text PosGUI=0"
			ControllerRef="EnumRef=Can.ControllerList PosGUI=1"
			>
		<HthList Max="65535">
			<Hth
				Name="Text Comment=(Name must be unique) PosGUI=0"
				HthRef="EnumRef=Can.ControllerList.(Self.Parent.Parent.ControllerRef).HohList Filter=(ObjectType==TRANSMIT) PosGUI=1"
				>
				<PduList Max="65535">
					<Pdu
						Name="Text Comment=(Name must be unique) PosGUI=0"
						EcuCPduRef="EnumRef=EcuC.PduList PosGUI=1"
						Identifier="Integer Range=0~0x1FFFFFFFF PosGUI=2"
						TransmitNotifier="Enum=(Nobody,PduR,CanTp,CanNm,J1939Tp,User) Default=PduR PosGUI=3"
						UserNotification="Text Default=CanIf_UserTxConfirmation PosGUI=4 Enabled=(Self.TransmitNotifier==User)"
						DataLengthCode="Integer Range=1~8 Default=8 PosGUI=5"
						>
					</Pdu>
				</PduList>
			</Hth>
		</HthList>
		<HrhList Max="65535">
			<Hrh
				Name="Text Comment=(Name must be unique) PosGUI=0"
				HrhRef="EnumRef=Can.ControllerList.(Self.Parent.Parent.ControllerRef).HohList Filter=(ObjectType==RECEIVE) PosGUI=1"
				SoftwareFilterUsed="Boolean Default=True PosGUI=2"
				>
				<PduList Max="65535">
					<Pdu
						Name="Text Comment=(Name must be unique) PosGUI=0"
						EcuCPduRef="EnumRef=EcuC.PduList PosGUI=1"
						Identifier="Integer Range=0~0x1FFFFFFFF PosGUI=2"
						FilterMask="Integer Range=0~0x1FFFFFFFF PosGUI=3 \n Enabled=(Self.Parent.Parent.SoftwareFilterUsed==True) \n Comment=(If $FilterMask and `Identifier==$Identifier, then valid)"
						ReceivedNotifier="Enum=(Nobody,PduR,CanTp,CanNm,J1939Tp,User) Default=PduR PosGUI=4"
						UserNotification="Text Default=CanIf_UserRxIndication PosGUI=5 Enabled=(Self.ReceivedNotifier==User)"
						DataLengthCode="Integer Range=1~8 Default=8 PosGUI=6"
						>
					</Pdu>
				</PduList>
			</Hrh>
		</HrhList>		
		</Channel>
	</ChannelList>
</CanIf>
<CanTp>
	<General
		DevelopmentErrorDetection="Enum=(ON,OFF) Default=OFF PosGUI=0"
		VersionInfoApi="Enum=(ON,OFF) Default=OFF PosGUI=1"
		>
	</General>	
	<RxSduList Max="65535">
		<Sdu
			Name="Text PosGUI=0"
			RxPduRef="EnumRef=EcuC.PduList PosGUI=1"
			TxFcPduRef="EnumRef=EcuC.PduList PosGUI=2"
			Padding="Enum=(ON,OFF) Default=ON Comment=(If ON,Padding value is 0x55) PosGUI=3"
			CommunicationType="Enum=(PHYSICAL,FUNCTION) Default=PHYSICAL Enabled=False \n Comment=(Only Physical is supported) PosGUI=4"
			BS="Integer Range=0~255 Default=8 PosGUI=5 \n Comment=(MaxReceiveBlockSize:If BS=0, no restrict.) "
			STmin="Integer Range=0~255 Default=1 Unit=ms PosGUI=6 Comment=(minimum transmission delay)"
			MaxBusyTransmission="Integer Range=0~255 Comment=(? ~_~ ?) PosGUI=7"
			Nar="Integer Range=0~255 Default=1 PosGUI=8 \n Unit=ms \n Comment=(transmission time)"
			Nbr="Integer Range=0~255 Default=100 PosGUI=9 \n Unit=ms \n Comment=(transmission time untill flow control)"
			Ncr="Integer Range=0~255 Default=1 PosGUI=10 \n Unit=ms \n Comment=(transmission request delay)"
			>
		</Sdu>
	</RxSduList>
	<TxSduList Max="65535">
		<Sdu
			Name="Text PosGUI=0"
			TxPduRef="EnumRef=EcuC.PduList PosGUI=1"
			RxFcPduRef="EnumRef=EcuC.PduList PosGUI=2"
			Padding="Enum=(ON,OFF) Default=ON Comment=(If ON,Padding value is 0x55) PosGUI=3"
			CommunicationType="Enum=(PHYSICAL,FUNCTION) Default=PHYSICAL Enabled=False \n Comment=(Only Physical is supported) PosGUI=4"
			Nas="Integer Range=0~255 Default=1 PosGUI=5 \n Unit=ms \n Comment=(transmission time)"
			Nbs="Integer Range=0~255 Default=100 PosGUI=6 \n Unit=ms \n Comment=(transmission time untill flow control)"
			Ncs="Integer Range=0~255 Default=1 PosGUI=7 \n Unit=ms \n Comment=(transmission request delay)"
			>
		</Sdu>
	</TxSduList>
</CanTp>
<PduR>
	<General
		DevelopmentErrorDetection="Enum=(ON,OFF) Default=OFF PosGUI=0"
		VersionInfoApi="Enum=(ON,OFF) Default=OFF PosGUI=1"
		ZeroCostOperationMode="Enum=(ON,OFF) Default=OFF PosGUI=2"
		ZeroCostIf="Enum=(CanIf,LinIf) Default=CanIf Enabled=(Self.ZeroCostOperationMode==ON) PosGUI=3"
		ZeroCostTp="Enum=(CanTp,LinTp,J1939Tp) Default=CanTp Enabled=(Self.ZeroCostOperationMode==ON) PosGUI=4"
		CanIfUsed="Boolean Default=True PosGUI=5"
		CanTpUsed="Boolean Default=True PosGUI=6"
		LinIfUsed="Boolean Default=False PosGUI=7"
		LinTpUsed="Boolean Default=False PosGUI=8"
		ComUsed="Boolean Default=True PosGUI=9"
		DcmUsed="Boolean Default=True PosGUI=10"
		J1939TpUsed="Boolean Default=False PosGUI=11"
		>
	</General>	
	<RoutineList Max="65535">
		<Source 
			Name="Text PosGUI=0"
			Module="Enum=(Com,Dcm,CanTp,CanIf,LinTp,LinIf,J1939Tp) Default=Com PosGUI=1"
			PudRef="EnumRef=EcuC.PduList PosGUI=2"
			>
			<DestinationList Max="65535">
				<Destination
					Name="Text PosGUI=0"
					Module="Enum=(Com,Dcm,CanTp,CanIf,LinTp,LinIf,J1939Tp) Default=Com PosGUI=1"
					PudRef="EnumRef=EcuC.PduList PosGUI=2"
					>
				</Destination>
			</DestinationList>
		</Source>
	</RoutineList>
</PduR>
<Com>
	<General
		DevelopmentErrorDetection="Enum=(ON,OFF) Default=OFF PosGUI=0"
		VersionInfoApi="Enum=(ON,OFF) Default=OFF PosGUI=1"
		>
	</General>
	<PduGroupList Max="255">
		<PduGroup 
			Name="Text PosGUI=0"
			>
		</PduGroup>
	</PduGroupList>
	<IPduList Max="255">
		<IPdu 
			Name="Text PosGUI=0" 
			PudRef="EnumRef=EcuC.PduList PosGUI=1"
			Direction="Enum=(SEND,RECEIVE) Default=SEND PosGUI=2"
			PduGroupRef="EnumRef=Com.PduGroupList PosGUI=3"
			Callout="Text Default=NULL Comment=(Ask application permission) PosGUI=4" 
			RxSignalProcessing="Enum=(DEFERRED,IMMEDIATE) Default=DEFERRED Enabled=(Self.Direction==RECEIVE) PosGUI=5"
			TxMinimumDelayFactor="Integer Range=0~255 Default=1 Enabled=(Self.Direction==SEND) PosGUI=6"
			DefaultValueForUnusedArea="Integer Range=0~255 Default=0x5A Enabled=(Self.Direction==SEND) PosGUI=7"
			TxMode="Enum=(NONE,DIRECT,PERIODIC,MIXED) Default=PERIODIC Enabled=(Self.Direction==SEND) PosGUI=8"
			NumberOfRepetions="Integer Range=0~255 Default=0 \n Enabled=(Self.TxMode==DIRECT || Self.TxMode==MIXED and Self.Direction==SEND) PosGUI=9"
			RepetionsPeriodFactor="Integer Range=0~255 Default=10 \n Enabled=(Self.TxMode==DIRECT || Self.TxMode==MIXED and Self.Direction==SEND) PosGUI=10 \n Unit=ms"
			TimeOffsetFactor="Integer Range=0~255 Default=0 \n Enabled=(Self.TxMode==PERIODIC || Self.TxMode==MIXED and Self.Direction==SEND) PosGUI=11 \n Unit=ms"
			TimePeriodFactor="Integer Range=0~255 Default=10 \n Enabled=(Self.TxMode==PERIODIC || Self.TxMode==MIXED and Self.Direction==SEND) PosGUI=12 \n Unit=ms"
			>
			<SignalList Max="64">
				<Signal 
					Name="Text PosGUI=0"
					Type="Enum=(uint8,uint16,uint32,uint8_n,uint16_n,uint32_n) Default=uint8 PosGUI=1"
					Endianess="Enum=(BIG_ENDIAN,LITTLE_ENDIAN,OPAQUE) Default=BIG_ENDIAN PosGUI=2"
					TransferProperty="Enum=(TRIGGERED,PENDING) Default=PENDING PosGUI=3 \n Enabled=(Self.Parent.Parent.Direction==SEND)"
					StartBit="Integer Range=0~63 PosGUI=4"
					Size="Integer Range=1~64 Default=8 PosGUI=5"
					InitialValue="Text Default=0 PosGUI=6"
					UpdateBitUsed="Boolean Default=False PosGUI=7"
					UpdateBitPosition="Integer Range=0~63 Enabled=(Self.UpdateBitUsed==True) PosGUI=8"
					TimeoutFactor="Integer Unit=ms \n Enabled=(Self.Parent.Parent.Direction==RECEIVE) PosGUI=9"
					FirstTimeoutFactor="Integer Unit=ms \n Enabled=(Self.Parent.Parent.Direction==RECEIVE) PosGUI=10"
					TimeoutAction="Enum=(RESET,NONE) Default=NONE \n Enabled=(Self.Parent.Parent.Direction==RECEIVE) PosGUI=11"
					TimeoutNotification="Text Default=NULL \n Enabled=(Self.Parent.Parent.Direction==RECEIVE) PosGUI=12"
					ReceivedNotification="Text Default=NULL \n Enabled=(Self.Parent.Parent.Direction==RECEIVE) PosGUI=13"
					>
				</Signal>
				<GroupSignal
					Name="Text PosGUI=0"
					Endianess="Enum=(BIG_ENDIAN,LITTLE_ENDIAN,OPAQUE) Default=BIG_ENDIAN PosGUI=1"
					TransferProperty="Enum=(TRIGGERED,PENDING) Default=PENDING PosGUI=2 \n Enabled=(Self.Parent.Parent.Direction==SEND)"
					StartBit="Integer Range=0~63 PosGUI=3"
					Size="Integer Range=1~64 Default=8 PosGUI=4"
					UpdateBitUsed="Boolean Default=False PosGUI=5"
					UpdateBitPosition="Integer Range=0~63 Enabled=(Self.UpdateBitUsed==True) PosGUI=6"
					TimeoutFactor="Integer Unit=ms \n Enabled=(Self.Parent.Parent.Direction==RECEIVE) PosGUI=7"
					FirstTimeoutFactor="Integer Unit=ms \n Enabled=(Self.Parent.Direction==RECEIVE) PosGUI=8"
					TimeoutAction="Enum=(RESET,NONE) Default=NONE \n Enabled=(Self.Parent.Parent.Direction==RECEIVE) PosGUI=9"
					TimeoutNotification="Text Default=NULL \n Enabled=(Self.Parent.Parent.Direction==RECEIVE) PosGUI=10"
					ReceivedNotification="Text Default=NULL \n Enabled=(Self.Parent.Parent.Direction==RECEIVE) PosGUI=11"
					>
					<SignalList Max="64">
						<Signal 
							Name="Text PosGUI=0"
							Type="Enum=(uint8,uint16,uint32,uint8_n,uint16_n,uint32_n) Default=uint8 PosGUI=1"
							Endianess="Enum=(BIG_ENDIAN,LITTLE_ENDIAN,OPAQUE) Default=BIG_ENDIAN PosGUI=2"
							StartBit="Integer Range=0~63 PosGUI=3"
							Size="Integer Range=1~64 Default=8 PosGUI=4"
							UpdateBitUsed="Boolean Default=False PosGUI=5"
							UpdateBitPosition="Integer Range=0~63 Enabled=(Self.UpdateBitUsed==True) PosGUI=6"
							InitialValue="Text Default=0 PosGUI=7"
							>
						</Signal>
				</SignalList>
				</GroupSignal>
			</SignalList>
		</IPdu>
	</IPduList>
</Com>
</AUTOSAR>
