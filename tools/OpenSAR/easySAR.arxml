<?xml version='1.0' encoding='utf-8'?>
<AUTOSAR>
<OS>
	<TaskList Max="255">
		<Task  
			Name="Text" 
			Priority="Integer Range=0~255" 
			Schedule="Enum=(FULL,NON,MIXED)" 
			StackSize="Integer Range=0~65535" 
			Activation="Integer Range=0~255" 
			Autostart="Boolean">
		<EventList Max="32">
		<Event 
			Name="Text" 
			Mask="Text"/>
		</EventList>
		</Task>
	</TaskList>
	<AlarmList Max="255">
		<Alarm 
			Name="Text" 
			Counter="EnumRef=OS.CounterList"
			Action ="Enum=(ActivateTask,SetEvent,Callback)"
			Task="EnumRef=OS.TaskList Enabled=(Self.Action==ActivateTask || Self.Action==SetEvent)"
			Event="EnumRef=OS.TaskList.(Self.Task).EventList Enabled=(Self.Action==SetEvent)"
			Callback="Text Enabled=(Self.Action==Callback)"
			>
		</Alarm>
	</AlarmList>
	<CounterList Max="255">
		<Counter Name="Text" >
		</Counter>
	</CounterList>
</OS>
<COM>
	<PduList Max="255">
		<Pdu 
			Name="Text" 
			Identifier="Integer Range=0~0x1FFFFFFFF" 
			Period="Interger Range=0~65535 Unit=ms">
			<SignalList Max="64">
				<Signal 
					Name="Text" 
					Size="Integer Range=0~64" 
					Type="Enum=(uint8,uint16,uint32,uint8_n,uint16_n,uint32_n)"
					Format="Enum=(Motorola,Intel)"/>
			</SignalList>
		</Pdu>
	</PduList>
</COM>
</AUTOSAR>
