<?xml version='1.0' encoding='utf-8'?>
<AUTOSAR>
<OS>
	<General
		StartupHook="Text Default=StartupHook Comment=(if NULL,no StartupHook) PosGUI=0"
		ProtectionHook="Text Default=ProtectionHook Comment=(if NULL,no ProtectionHook) PosGUI=1"
		ShutdownHook="Text Default=ShutdownHook Comment=(if NULL,no ShutdownHook) PosGUI=2"
		ErrorHook="Text Default=ErrorHook Comment=(if NULL,no ErrorHook) PosGUI=3"
		PreTaskHook="Text Default=PreTaskHook Comment=(if NULL,no PreTaskHook) PosGUI=4"
		PostTaskHook="Text Default=PostTaskHook Comment=(if NULL,no PostTaskHook) PosGUI=5"
	/>
	<TaskList Max="255">
		<Task  
			Name="Text Comment=(Task Name) PosGUI=0" 
			Priority="Integer Default=32 Range=0~255 PosGUI=1" 
			Schedule="Enum=(FULL,NON,MIXED) Default=FULL PosGUI=2" 
			StackSize="Integer Range=0~65535 Default=512 PosGUI=3" 
			Activation="Integer Range=1~255 Default=1 PosGUI=4" 
			Autostart="Boolean Default=True PosGUI=5" >
		<EventList Max="32">
		<Event 
			Name="Text PosGUI=0" 
			Mask="Text Comment=(if TBD, then a unique mask will be calculated out when generate OS) PosGUI=1">
		</Event>
		</EventList>
		</Task>
	</TaskList>
	<AlarmList Max="255">
		<Alarm 
			Name="Text PosGUI=0" 
			Counter="EnumRef=OS.CounterList PosGUI=1"
			Action="Enum=(ActivateTask,SetEvent,Callback) Default=ActivateTask PosGUI=2"
			Task="EnumRef=OS.TaskList Enabled=(Self.Action==ActivateTask || Self.Action==SetEvent) PosGUI=3"
			Event="EnumRef=OS.TaskList.(Self.Task).EventList Enabled=(Self.Action==SetEvent) PosGUI=4"
			Callback="Text Enabled=(Self.Action==Callback) PosGUI=5"
			Autostart="Enum=(False,Absolute,Relative) Default=False PosGUI=6"
			StartTime="Integer Range=0~65525 Enabled=(Self.Autostart!=False) Default=0 PosGUI=7"
			Period="Integer Range=0~65535 Enabled=(Self.Autostart!=False) Default=100 PosGUI=8">
		</Alarm>
	</AlarmList>
	<CounterList Max="255">
		<Counter 
			Name="Text Comment=(The first counter is treated as system tick counter) PosGUI=0" 
			MaxAllowed="Integer Range=0~0xFFFFFFFF Default=0xFFFF PosGUI=1"
			TicksPerBase="Integer Range=0~0xFFFF Default=1 Enabled=(False) PosGUI=2"
			MinCycle="Integer Range=0~0xFFFF Default=1 PosGUI=3">
		</Counter>
	</CounterList>
	<ResourceList Max="255">
		<Resource 
			Name="Text PosGUI=0">
		</Resource>
	</ResourceList>
</OS>
<EucC>
	<PduList Max="65535">
		<Pdu
			Name="Text PosGUI=0"
			Size="Integer Default=64 Range=1~64 PosGUI=1 Unit=Bit"
		/>
	</PduList>
</EucC>
<Can>
	<General
		DevelopmentErrorDetection="Enum=(ON,OFF) Default=OFF PosGUI=0"
		VersionInfoApi="Enum=(ON,OFF) Default=OFF PosGUI=1"
		>
	</General>
	<ControllerList Max="5">
		<Controller
			Name="Enum=(CAN_CTRL_0,CAN_CTRL_1,CAN_CTRL_2,CAN_CTRL_3,CAN_CTRL_4) PosGUI=0"
			Baudrate="Integer Range=1~12000000 Default=500 Unit=kbps PosGUI=1"
			Seg1="Integer Range=1~16 Default=13 PosGUI=2"
			Seg2="Integer Range=1~8 Default=2 PosGUI=3"
			>
			<HohList Max="65535">
				<Hoh
					Name="Text Comment=(Name must be unique) PosGUI=0"
					HohType="Enum=(BASIC,FULL) Default=BASIC PosGUI=1"
					IdentifierType="Enum=(STANDARD,EXTENDED) Default=STANDARD PosGUI=2"
					ObjectType="Enum=(TRANSMIT,RECEIVE) PosGUI=3"
					/>
			</HohList>
		</Controller>
	</ControllerList>
</Can>
<CanIf>
	<General
		DevelopmentErrorDetection="Enum=(ON,OFF) Default=OFF PosGUI=0"
		VersionInfoApi="Enum=(ON,OFF) Default=OFF PosGUI=1"
		BusOffNotification="Text Default=CanIf_User_BusoffNotification PosGUI=2"
		ErrorNotification="Text Default=CanIf_User_ErrorNotification PosGUI=3"
		DataLengthCodeCheck="Enum=(ON,OFF) Default=ON PosGUI=4"
		>
	</General>	
	<ChannelList Max="65535">
		<Channel
			Name="Text PosGUI=0"
			ControllerRef="EnumRef=Can.ControllerList PosGUI=1"
			>
		<HthList Max="65535">
			<Hth
				Name="Text Comment=(Name must be unique) PosGUI=0"
				HthRef="EnumRef=Can.ControllerList.(Self.Parent.Parent.ControllerRef).HohList Filter=(ObjectType==TRANSMIT) PosGUI=1"
				>
			</Hth>
		</HthList>
		<HrhList Max="65535">
			<Hrh
				Name="Text Comment=(Name must be unique) PosGUI=0"
				HrhRef="EnumRef=Can.ControllerList.(Self.Parent.Parent.ControllerRef).HohList Filter=(ObjectType==RECEIVE) PosGUI=1"
				SoftwareFilterUsed="Boolean Default=True PosGUI=2"
				>
			</Hrh>
		</HrhList>		
		</Channel>
	</ChannelList>
</CanIf>
<COM>
	<BusList Max="8">
		<Bus 
			Name="Text PosGUI=0"
			Baudrate="Integer Unit=Kbp PosGUI=1"
			SyncSeg="Integer PosGUI=2"
			Seg1="Integer PosGUI=3"
			Seg2="Integer PosGUI=4">
		</Bus>
	</BusList>
	<TxPduList Max="255">
		<Pdu 
			Name="Text PosGUI=0" 
			Identifier="Integer Range=0~0x1FFFFFFFF PosGUI=1" 
			TxMode="Enum=(DIRECT,PERIODIC,MIXED,NONE) Default=PERIODIC PosGUI=2"
			Period="Integer Range=0~65535 Default=100 Unit=ms Enabled=(Self.TxMode==PERIODIC || Self.TxMode==MIXED) PosGUI=3"
			Format="Enum=(Motorola,Intel) Default=Motorola PosGUI=4"
			Bus="EnumRef=COM.BusList PosGUI=5">
			<SignalList Max="64">
				<Signal 
					Name="Text PosGUI=0"
					Type="Enum=(uint8,uint16,uint32,uint8_n,uint16_n,uint32_n) Default=uint8 PosGUI=1"
					StartBit="Integer Range=0~63 PosGUI=2"
					Size="Integer Range=1~64 Default=8 PosGUI=3"
					InitialValue="Text Default=0 PosGUI=4"
					UpdateBitUsed="Boolean Default=False PosGUI=5"
					UpdateBitPosition="Integer Range=0~63 Enabled=(Self.UpdateBitUsed==True) PosGUI=6"
					TransferProperty="Enum=(TRIGGERED,PENDING) Default=PENDING PosGUI=7"
					>
				</Signal>
			</SignalList>
		</Pdu>
	</TxPduList>
	<RxPduList Max="255">
		<Pdu 
			Name="Text PosGUI=0" 
			Identifier="Integer Range=0~0x1FFFFFFFF PosGUI=1" 
			RxMode="Enum=(DIRECT,PERIODIC,MIXED,NONE) Default=PERIODIC PosGUI=2"
			Timeout="Integer Range=0~65535 Default=2000 Unit=ms Enabled=(Self.RxMode==PERIODIC || Self.RxMode==MIXED) PosGUI=3"
			TimeoutNotification="Text \n Comment=(For AUTOSAR,Notifications are about signals.\nFor easy Notification, so the first signal of this PDU will have Notification mechanism when generate.) \n Enabled=(Self.RxMode==PERIODIC || Self.RxMode==MIXED) PosGUI=4"
			Format="Enum=(Motorola,Intel) Default=Motorola PosGUI=5"
			Bus="EnumRef=COM.BusList PosGUI=6">
			<SignalList Max="64">
				<Signal 
					Name="Text PosGUI=0"
					Type="Enum=(uint8,uint16,uint32,uint8_n,uint16_n,uint32_n) Default=uint8 PosGUI=1"
					StartBit="Integer Range=0~63 PosGUI=2"
					Size="Integer Range=1~64 Default=8 PosGUI=3"
					InitialValue="Text Default=0 PosGUI=4"
					UpdateBitUsed="Boolean Default=False PosGUI=5"
					UpdateBitPosition="Integer Range=0~63 Enabled=(Self.UpdateBitUsed==True) PosGUI=6"
					TransferProperty="Enum=(TRIGGERED,PENDING) Default=PENDING PosGUI=7"
					>
				</Signal>
			</SignalList>
		</Pdu>
	</RxPduList>
</COM>
</AUTOSAR>
